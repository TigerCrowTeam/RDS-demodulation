options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: fm_rxRDS02
    output_language: python
  states: {}

blocks:
- name: BPSKconst
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: inputSampRate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: sampRate
  id: variable
  parameters:
    value: '19000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '-18500'
    low_cutoff_freq: '-19500'
    samp_rate: inputSampRate
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1000000'
    high_cutoff_freq: '-56500'
    low_cutoff_freq: '-57500'
    samp_rate: inputSampRate
    type: fir_filter_ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: outputRDS1.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: gqrx_20250520_173802_101100000_960000_fc.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: inputSampRate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: BPSKconst
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '.01'
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '7000'
    decim: '1'
    gain: '20'
    samp_rate: inputSampRate
    type: fir_filter_ccf
    width: '700'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '500'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(inputSampRate/1000)
    interp: int(sampRate/1000)
    type: ccf
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '16'
    gain: '1'
    ntaps: '8'
    samp_rate: sampRate
    sym_rate: '1187.5'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_0, '0', blocks_multiply_xx_1, '2']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_1, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_1, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_xx_1, '0', band_pass_filter_0_0, '0']
- [blocks_null_source_1, '0', blocks_float_to_complex_1, '1']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0, '0']
- [digital_costas_loop_cc_0, '0', root_raised_cosine_filter_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', digital_costas_loop_cc_0, '0']
- [root_raised_cosine_filter_0, '0', digital_constellation_decoder_cb_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
